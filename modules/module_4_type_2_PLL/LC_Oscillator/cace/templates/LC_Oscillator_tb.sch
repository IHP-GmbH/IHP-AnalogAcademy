** sch_path: modules/module_4_type_2_PLL/LC_Oscillator/cace/templates/LC_Oscillator_tb.sch
**.subckt LC_Oscillator_tb Voplus Vominus VDD
*.opin Voplus
*.opin Vominus
*.iopin VDD
V1 VDD GND CACE{vdd}
x1 Voplus VDD GND Vominus LC_Oscillator
**** begin user architecture code


.ic V(Voplus)=1.2
.control
set noaskquit
set numdgt=12

* Save & simulate
save all
op
write LC_Oscillator_tb.raw
set appendwrite
tran 10p 10n 160p
save all

* Explicit vectors
let vo_p    = v(Voplus)
let vo_m    = v(Vominus)
let vo_diff = vo_p - vo_m

set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data vo_diff
quit

.endc



.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

**** end user architecture code
**.ends

* expanding   symbol:  LC_Oscillator.sym # of pins=4
** sym_path: modules/module_4_type_2_PLL/LC_Oscillator/xschem/LC_Oscillator.sym
** sch_path: modules/module_4_type_2_PLL/LC_Oscillator/xschem/LC_Oscillator.sch
.subckt LC_Oscillator Voplus vdd gnd Vominus
*.iopin vdd
*.iopin gnd
*.opin Voplus
*.opin Vominus
XM1 Voplus Vominus net1 gnd sg13_lv_nmos w=16u l=0.13u ng=4 m=1 mm_ok=1
XM2 Vominus Voplus net1 gnd sg13_lv_nmos w=16u l=0.13u ng=4 m=1 mm_ok=1
R2 vdd Vominus 393 m=1
I0 net1 gnd 1m
L1 vdd Vominus 1.56n m=1
R1 vdd Voplus 393 m=1
L2 vdd Voplus 1.56n m=1
C1 Voplus gnd 400f m=1
C2 Vominus gnd 400f m=1
.ends

.GLOBAL GND
.end
